RDEPENDS_${PN}_remove = " \
    tensorflow-lite \
"
