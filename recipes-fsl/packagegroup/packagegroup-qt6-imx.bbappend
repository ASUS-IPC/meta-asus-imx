RDEPENDS:${PN}:remove= " \
    nxp-demo-experience \
"
