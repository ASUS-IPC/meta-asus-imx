RDEPENDS_${PN}_remove_imxgpu = " \
    qt5everywheredemo \
"
