RDEPENDS_${PN}_remove = " \
    nxp-demo-experience \
"