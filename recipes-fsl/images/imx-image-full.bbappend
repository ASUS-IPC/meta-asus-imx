TOOLCHAIN_TARGET_TASK_remove = " \
    tensorflow-lite-staticdev \
"
