
RDEPENDS:${PN}:remove = " \
    packagegroup-imx-gopoint \
    "
