# add go-systemd branch name
SRCNAME = "systemd"
PKG_NAME = "github.com/coreos/go-${SRCNAME}"

SRC_URI = "git://${PKG_NAME}.git;protocol=https;branch=main"
