SRC_URI_remove = "http://linuxcontainers.org/downloads/${BPN}-${PV}.tar.gz"

SRC_URI_append = "https://linuxcontainers.org/downloads/${BPN}/${BPN}-${PV}.tar.gz"
