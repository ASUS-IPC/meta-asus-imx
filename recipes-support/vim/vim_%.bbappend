PACKAGECONFIG:remove:asus= "x11"