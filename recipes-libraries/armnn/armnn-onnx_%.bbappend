
SRC_URI = "git://github.com/onnx/onnx.git;branch=main"

