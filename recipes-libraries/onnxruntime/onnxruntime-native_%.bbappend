GIT_protobuf = "git://github.com/google/protobuf.git;branch=main;name=protobuf"