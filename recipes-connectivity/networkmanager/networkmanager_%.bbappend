PACKAGECONFIG:append = "nmtui "

