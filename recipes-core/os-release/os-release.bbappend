EXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

OS_RELEASE_FIELDS += "BUILD_ID BUILD_VERSION"
BUILD_VERSION = "${IMAGE_VERSION}"
